# Keil uVision project Fly-Balance.uvprojx, settings and files
target Fly-Balance_master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CH32F203C8 WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fly-Balance +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MPU6500
  c include: ..\SRC\StdPeriphDriver\inc;..\SRC\CMSIS;..\SRC\Debug;..\Project;..\BSP\include;..\Device\include;..\Algorithm\include;..\Control\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: ch32f20x_it.c system_ch32f20x.c main.c
  group control
    ../Control/source/: common.c fly.c car.c
  group device
    ../Device/source/: led.c motor.c niming.c nrf24l01.c mpu6500.c encoder.c
  group algorithm
    ../Algorithm/source/: pid.c filter.c
  group bsp
    ../BSP/source/: bsp_i2c.c bsp_uart.c bsp_spi.c bsp_systick.c bsp_pwm.c bsp_adc.c bsp_tim.c bsp_encoder.c bsp_iwdg.c
  group startup
    ../SRC/Startup/: startup_ch32f20x_D6.s
  group core
    ../SRC/CMSIS/: core_cm3.c
  group fwlib
    ../SRC/StdPeriphDriver/src/: ch32f20x_gpio.c ch32f20x_i2c.c ch32f20x_spi.c ch32f20x_tim.c ch32f20x_usart.c ch32f20x_adc.c ch32f20x_rcc.c ch32f20x_misc.c ch32f20x_exti.c ch32f20x_dma.c ch32f20x_iwdg.c
